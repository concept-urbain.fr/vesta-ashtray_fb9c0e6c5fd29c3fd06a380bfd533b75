Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Vesta Cendrier sur platine.IFC
Time: 2020-05-20T09:06:58
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: VEST-CEN-MUL-002-01_Default
In: Default Storey
Material: 0

# IfcBeam: VEST-CEN-MUL-003-01_Default
In: Default Storey
Material: 0

# IfcBeam: VEST-CEN-MUL-003-02_Default (2)
In: Default Storey
Material: 0

# IfcBeam: VEST-CEN-PLA-002-02_Default
In: Default Storey
Material: 0

# IfcBeam: VEST-CEN-PLA-003_Default
In: Default Storey
Material: 0

# IfcBuildingElementProxy: STHC-PLAT-M6x10-A2_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: VEST-CEN-MUL-002-02_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: VEST-CEN-MUL-002-03_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: VEST-CEN-MUL-003-02_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: VEST-CEN-PLA-002-01_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: VEST-CEN-PLA-002-02_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: VEST-MUL-014_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0
